IMAGE_INSTALL_append = " greengrass"
IMAGE_INSTALL_append = " aws-greengrass-core-sdk-python aws-greengrass-core-sdk-c"
IMAGE_INSTALL_append = " websocket-tunnel shellinabox openfortivpn"
